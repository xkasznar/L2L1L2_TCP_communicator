options:
  parameters:
    generate_options: no_gui
    id: server
    output_language: python
    title: server
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}

connections:
- [network_socket_pdu_0, pdus, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
