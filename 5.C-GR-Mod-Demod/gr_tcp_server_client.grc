options:
  parameters:
    generate_options: qt_gui
    id: gr_tcp_server_client
    output_language: python
    title: gr_tcp_server_client
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cmaEqualizer
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 1,10,1,10
    gui_hint: 1,10,1,10
    label: Delay
    start: '0'
    step: '1'
    stop: '500'
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 1,0,1,10
    gui_hint: 1,0,1,10
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: loop_order
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 0,0,1,10
    gui_hint: 0,0,1,10
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.3'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1,samp_rate,samp_rate/float(sps),excess_bw,11*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 0,10,1,10
    gui_hint: 0,10,1,10
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.000'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_2
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '300'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (10, -10)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (10j, -10j)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: loop_order
    w: timing_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: TCP_CLIENT
  states: {}
- name: network_socket_pdu_2
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '0.3'
    alpha3: '0.3'
    color3: '"red"'
    comment: 2,0,10,10
    grid: 'True'
    gui_hint: 2,0,10,10
    legend: 'False'
    marker2: '-1'
    marker3: '-1'
    name: Recovered Constellation
    nconnections: '3'
    size: '1024'
    style2: '1'
    style3: '1'
    type: complex
    width2: '2'
    width3: '2'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 12,0,10,20
    fc: '0'
    fftsize: '4096'
    gui_hint: 12,0,10,20
    label1: Received Spectrum
    label2: Filtered Spectrum
    nconnections: '2'
    type: complex
    ymax: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 2,10,10,10
    gui_hint: 2,10,10,10
    label1: Rx Bits
    label2: Diff
    label3: Tx Bits
    name: ''
    nconnections: '3'
    size: '64'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_pack_k_bits_bb_2, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_vector_source_x_0_0, '0', qtgui_const_sink_x_0, '2']
- [channels_channel_model_0, '0', fft_filter_xxx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_pack_k_bits_bb_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fft_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [network_socket_pdu_2, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, network_socket_pdu_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
